## drivers/disableversioncheck/Kconfig
```kconfig
config DISABLEVERSIONCHECK
        tristate "dynamically disable version-check for kernel-modules"
        depends on SYMSEARCH
```
